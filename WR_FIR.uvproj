# Keil uVision project WR_FIR.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: WR_FIR +hex
  c flags: Optim=3
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\bsp;.\CM3;.\user;.\STM32F10x_StdPeriph_Driver;.\APP;.\STM32F10x_StdPeriph_Driver\inc;.\OS\core;.\OS\port
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STM32F10X_CM3
    ./: startup_stm32f10x_md.s
    ./CM3/: core_cm3.c
  group STM32F10X_LIB
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_dma.c
  group BSP
    ./bsp/: si4432.c base.c STM32Init.c bsp.c Encrypt.c spi.c DataFlash.c IWatchDog.c
  group APP
    ./APP/: stm32f10x_it.c App.c protocol.c taskProtocol.c taskProtoSend.c taskTest.c taskSet.c taskSi4432Read.c remote_urc_index.c remote_UART_PRO.c remote_ioctl.c
  group uCOSii_CORE
    ./OS/core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOSii_PROT
    ./OS/port/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
